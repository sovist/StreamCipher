# IAR project STK526-series2-hidio.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: usb162 AT90USB162
  ICCAVR.CCDiagSuppress: Pe111,Pe550
  ICCAVR.newCCIncludePaths: ..; ../conf; ../../../
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkusb162s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: hid_task.c main.c usb_descriptors.c usb_specific_request.c
    ../nRF240L01/: nRF24L01.c
    ../../../lib_mcu/power/: power_drv.c
    ../../../modules/scheduler/: scheduler.c
    ../spi_driver/: spi_driver.c
    ../../../lib_mcu/util/: start_boot.c
    ../../../lib_board/stk_526/: stk_526.h
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
    ../../../lib_mcu/wdt/: wdt_drv.c
